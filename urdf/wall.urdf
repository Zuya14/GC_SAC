Commit message: fix bug lidar and wall

File: urdf/wall.urdf (robot description, URDF)
Before this commit: robot wall, 1 links, 0 joints
Links:
- link origin: geometry collision box size=1 1 2; visual box size=1 1 2
